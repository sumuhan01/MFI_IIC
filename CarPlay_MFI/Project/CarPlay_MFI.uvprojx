# Keil uVision project CarPlay_MFI.uvprojx, settings and files
target MFI (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Project;..\CORE;..\USART;..\Common;..\IIC;..\ComM;..\Common\delay;..\Common\CORE;..\Common\sys;..\Common\STM32F10x_FWLib\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group FWLib
    ../Common/STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group USART
    ../USART/: Usart_Device.c Usart_Device.h Usart.c Usart.h
  group IIC
    ../IIC/: IIC_Device.c IIC_Device.h IIC.c IIC.h
  group ComM
    ../ComM/: ComM.c ComM.h
  group Common
    ../Common/: UserTypes.h
    ../Common/sys/: sys.c
    ../Common/delay/: delay.c
    ../Common/CORE/: core_cm3.c startup_stm32f10x_hd.s
